# IAR project uCOS-III.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 512
  General.GenNearHeapSize: 128
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: $PROJ_DIR$; Source; ..\uCOS-III; ..\BSP; ..\BSP\applilet3_src; ..\BSP\Glyph\Drivers; ..\BSP\Glyph\glyph; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\RL78\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-III\Ports\Renesas\RL78\IAR; ..\..\..\..\..\uCOS-III\Source
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f104pj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    Source/: accel.c app.c
  group BSP
    ../BSP/: bsp.c cpu_bsp.c
  group BSP/Applilet
    ../BSP/applilet3_src/: r_cg_adc.c r_cg_adc_user.c r_cg_cgc.c r_cg_cgc_user.c r_cg_intc.c r_cg_intc_user.c r_cg_it.c r_cg_it_user.c r_cg_port.c r_cg_port_user.c r_cg_serial.c r_cg_serial_user.c r_cg_timer.c r_cg_timer_user.c r_main.c r_systeminit.c
  group BSP/Glyph/Drivers
    ../BSP/Glyph/Drivers/: lcd.c ST7579_LCD.c YRDKRL78_SPI.c
  group BSP/Glyph/Fonts
    ../BSP/Glyph/Fonts/: bitmap_font.c font_8x16.c font_8x8.c font_helvr10.c font_logos.c font_winfreesystem14x16.c font_x5x7.c font_x6x13.c
  group BSP/Glyph/glyph
    ../BSP/Glyph/glyph/: glyph.c glyph_register.c
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/RL78/IAR
    ../../../../../uC-CPU/RL78/IAR/: cpu.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III/Ports/Renesas/RL78/IAR
    ../../../../../uCOS-III/Ports/Renesas/RL78/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../uCOS-III/: os_app_hooks.c
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
